# IAR project sai_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 Freescale MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK64FN1M0VMD12; IAR; MAPS_K64; MAPS
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../platform/utilities; ../../../../platform/osa; ../../../../platform/CMSIS/Include; ../../../../platform/CMSIS/Include/device; ../../../../platform/startup/MK64F12; ../../../../platform/hal; ../../../../platform/hal/adc; ../../../../platform/hal/can; ../../../../platform/hal/dac; ../../../../platform/hal/dmamux; ../../../../platform/hal/dspi; ../../../../platform/hal/edma; ../../../../platform/hal/enet; ../../../../platform/hal/flextimer; ../../../../platform/hal/flexbus; ../../../../platform/hal/gpio; ../../../../platform/hal/i2c; ../../../../platform/hal/lptmr; ../../../../platform/hal/mcg; ../../../../platform/hal/osc; ../../../../platform/hal/pdb; ../../../../platform/hal/pit; ../../../../platform/hal/pmc; ../../../../platform/hal/port; ../../../../platform/hal/rtc; ../../../../platform/hal/sai; ../../../../platform/hal/sdhc; ../../../../platform/hal/sim; ../../../../platform/hal/smc; ../../../../platform/hal/spi; ../../../../platform/hal/uart; ../../../../platform/hal/wdog; ../../../../platform/drivers; ../../../../platform/drivers/adc; ../../../../platform/drivers/adc/common; ../../../../platform/drivers/can; ../../../../platform/drivers/can/common; ../../../../platform/drivers/edma; ../../../../platform/drivers/edma/common; ../../../../platform/drivers/dac; ../../../../platform/drivers/dac/common; ../../../../platform/drivers/dspi/dspi_master; ../../../../platform/drivers/dspi/dspi_slave; ../../../../platform/drivers/dspi/common; ../../../../platform/drivers/enet; ../../../../platform/drivers/enet/common; ../../../../platform/drivers/enet/src; ../../../../platform/drivers/flash; ../../../../platform/drivers/flextimer; ../../../../platform/drivers/flextimer/common; ../../../../platform/drivers/gpio; ../../../../platform/drivers/gpio/common; ../../../../platform/drivers/i2c/i2c_master; ../../../../platform/drivers/i2c/i2c_slave; ../../../../platform/drivers/i2c/common; ../../../../platform/drivers/lptmr; ../../../../platform/drivers/lptmr/common; ../../../../platform/drivers/mmcau; ../../../../platform/drivers/pdb; ../../../../platform/drivers/pdb/common; ../../../../platform/drivers/pit; ../../../../platform/drivers/pit/common; ../../../../platform/drivers/rtc; ../../../../platform/drivers/rtc/common; ../../../../platform/drivers/sai; ../../../../platform/drivers/sai/common; ../../../../platform/drivers/sdhc; ../../../../platform/drivers/sdhc/common; ../../../../platform/drivers/sdcard; ../../../../platform/drivers/soundcard; ../../../../platform/drivers/spi; ../../../../platform/drivers/spi/common; ../../../../platform/drivers/uart; ../../../../platform/drivers/uart/common; ../../../../platform/drivers/wdog; ../../../../platform/drivers/wdog/common; ../../../../platform/system/clock; ../../../../platform/system/hwtimer; ../../../../platform/system/interrupt; ../../../../platform/system/power; ../../../../boards/common; ../../../../boards/common/wm8960; ../../../../boards/common/wm8960/src; ../../../../platform/drivers/soundcard; ../../../../platform/drivers/soundcard/src; ../../../../boards/mapsk64; C:\kinetis\MAPS Material\K64\MAPS-K64_1.0.0\demos\sai_demo\fatfs; C:\kinetis\MAPS Material\K64\MAPS-K64_1.0.0\demos\sai_demo\fatfs\sdmmc\inc; C:\kinetis\MAPS Material\K64\MAPS-K64_1.0.0\demos\sai_demo\fatfs\sdmmc\port; C:\kinetis\MAPS Material\K64\MAPS-K64_1.0.0\demos\sai_demo\fatfs\sdmmc\port\sdhc\interrupt; C:\kinetis\MAPS Material\K64\MAPS-K64_1.0.0\demos\sai_demo\fatfs\sdmmc\src; C:\kinetis\MAPS Material\K64\MAPS-K64_1.0.0\demos\sai_demo\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: sai_demo.out
  ILINK.IlinkIcfFile: ../../../../platform/linker/iar/K64F12/K64FN1Mxxx12_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../lib/ksdk_platform_lib/iar/K64F12/debug/ksdk_platform_lib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; CPU_MK64FN1M0VMD12; IAR; MAPS_K64; MAPS
  ICCARM.CCIncludePath2: ../../../../platform/utilities; ../../../../platform/osa; ../../../../platform/CMSIS/Include; ../../../../platform/CMSIS/Include/device; ../../../../platform/startup/MK64F12; ../../../../platform/hal; ../../../../platform/hal/adc; ../../../../platform/hal/can; ../../../../platform/hal/dac; ../../../../platform/hal/dmamux; ../../../../platform/hal/dspi; ../../../../platform/hal/edma; ../../../../platform/hal/enet; ../../../../platform/hal/flextimer; ../../../../platform/hal/flexbus; ../../../../platform/hal/gpio; ../../../../platform/hal/i2c; ../../../../platform/hal/lptmr; ../../../../platform/hal/mcg; ../../../../platform/hal/osc; ../../../../platform/hal/pdb; ../../../../platform/hal/pit; ../../../../platform/hal/pmc; ../../../../platform/hal/port; ../../../../platform/hal/rtc; ../../../../platform/hal/sai; ../../../../platform/hal/sdhc; ../../../../platform/hal/sim; ../../../../platform/hal/smc; ../../../../platform/hal/spi; ../../../../platform/hal/uart; ../../../../platform/hal/wdog; ../../../../platform/drivers; ../../../../platform/drivers/adc; ../../../../platform/drivers/adc/common; ../../../../platform/drivers/can; ../../../../platform/drivers/can/common; ../../../../platform/drivers/edma; ../../../../platform/drivers/edma/common; ../../../../platform/drivers/dac; ../../../../platform/drivers/dac/common; ../../../../platform/drivers/dspi/dspi_master; ../../../../platform/drivers/dspi/dspi_slave; ../../../../platform/drivers/dspi/common; ../../../../platform/drivers/enet; ../../../../platform/drivers/enet/common; ../../../../platform/drivers/enet/src; ../../../../platform/drivers/flash; ../../../../platform/drivers/flextimer; ../../../../platform/drivers/flextimer/common; ../../../../platform/drivers/gpio; ../../../../platform/drivers/gpio/common; ../../../../platform/drivers/i2c/i2c_master; ../../../../platform/drivers/i2c/i2c_slave; ../../../../platform/drivers/i2c/common; ../../../../platform/drivers/lptmr; ../../../../platform/drivers/lptmr/common; ../../../../platform/drivers/mmcau; ../../../../platform/drivers/pdb; ../../../../platform/drivers/pdb/common; ../../../../platform/drivers/pit; ../../../../platform/drivers/pit/common; ../../../../platform/drivers/rtc; ../../../../platform/drivers/rtc/common; ../../../../platform/drivers/sai; ../../../../platform/drivers/sai/common; ../../../../platform/drivers/sdhc; ../../../../platform/drivers/sdhc/common; ../../../../platform/drivers/sdcard; ../../../../platform/drivers/soundcard; ../../../../platform/drivers/spi; ../../../../platform/drivers/spi/common; ../../../../platform/drivers/uart; ../../../../platform/drivers/uart/common; ../../../../platform/drivers/wdog; ../../../../platform/drivers/wdog/common; ../../../../platform/system/clock; ../../../../platform/system/hwtimer; ../../../../platform/system/interrupt; ../../../../platform/system/power; ../../../../boards/common; ../../../../boards/common/wm8960; ../../../../boards/common/wm8960/src; ../../../../platform/drivers/soundcard; ../../../../platform/drivers/soundcard/src; ../../../../boards/mapsk64
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ../../../../lib/ksdk_platform_lib/iar/K64F12/release/ksdk_platform_lib.a
  group board
    ../../../../boards/mapsk64/: board.h gpio_pins.c gpio_pins.h hardware_init.c pin_mux.c pin_mux.h
  group codec
    ../../../../boards/common/wm8960/src/: fsl_wm8960_driver.c
    ../../../../boards/common/wm8960/: fsl_wm8960_driver.h
  group fatfs
    ../../fatfs/: diskio.c diskio.h ff.c ffconf.h ffsystem.c ffunicode.c fsl_sd_disk.c sdhc_sdcard.h
  group interrupt_handlers
    ../../../../platform/drivers/edma/: fsl_edma_irq.c
    ../../../../platform/drivers/i2c/: fsl_i2c_irq.c
    ../../../../platform/drivers/sai/: fsl_sai_irq.c
  group sdmmc/sdmmc-inc
    ../../fatfs/sdmmc/inc/: fsl_mmc.h fsl_sd.h fsl_sdio.h fsl_sdmmc_common.h fsl_sdmmc_host.h fsl_sdmmc_spec.h fsl_sdspi.h
  group sdmmc/sdmmc-port
    ../../fatfs/sdmmc/port/sdhc/interrupt/: fsl_sdmmc_event.c fsl_sdmmc_host.c
    ../../fatfs/sdmmc/port/: fsl_sdmmc_event.h
  group sdmmc/sdmmc-src
    ../../fatfs/sdmmc/src/: fsl_sd.c fsl_sdmmc_common.c
  group soundcard
    ../../../../platform/drivers/soundcard/src/: fsl_soundcard.c
    ../../../../platform/drivers/soundcard/: fsl_soundcard.h
  group source
    ../../src/: audio.c audio.h equalizer.c equalizer.h main.c terminal_menu.c terminal_menu.h
  group startup
    ../../../../platform/startup/: startup.c startup.h
    ../../../../platform/startup/MK64F12/iar/: startup_MK64F12.s
    ../../../../platform/startup/MK64F12/: system_MK64F12.c
  group utilities
    ../../../../platform/utilities/src/: fsl_debug_console.c
    ../../../../platform/utilities/: fsl_debug_console.h
