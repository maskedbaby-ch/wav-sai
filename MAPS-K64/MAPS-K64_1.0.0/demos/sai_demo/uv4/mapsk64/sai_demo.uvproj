# Keil uVision project sai_demo.uvproj, settings and files
target sai_demo Debug (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2002FFFF) IROM(0x0-0xFFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")  FPU2 ELITTLE
  output: sai_demo.out
  c flags: Optim=1 wLevel=2
  c define: DEBUG, ARM_MATH_CM4, CPU_MK64FN1M0VMD12, KEIL, MAPS_K64, MAPS
  c misc: --library_interface=armcc  --library_type=standardlib --c99 --diag_suppress=1296,186
  c include: ../../../../platform/utilities;../../../../platform/osa;../../../../platform/CMSIS/Include;../../../../platform/CMSIS/Include/device;../../../../platform/startup/MK64F12;../../../../platform/hal;../../../../platform/hal/adc;../../../../platform/hal/can;../../../../platform/hal/dac;../../../../platform/hal/dmamux;../../../../platform/hal/dspi;../../../../platform/hal/edma;../../../../platform/hal/enet;../../../../platform/hal/flextimer;../../../../platform/hal/flexbus;../../../../platform/hal/gpio;../../../../platform/hal/i2c;../../../../platform/hal/lptmr;../../../../platform/hal/mcg;../../../../platform/hal/osc;../../../../platform/hal/pdb;../../../../platform/hal/pit;../../../../platform/hal/pmc;../../../../platform/hal/port;../../../../platform/hal/rtc;../../../../platform/hal/sai;../../../../platform/hal/sdhc;../../../../platform/hal/sim;../../../../platform/hal/smc;../../../../platform/hal/spi;../../../../platform/hal/uart;../../../../platform/hal/wdog;../../../../platform/drivers;../../../../platform/drivers/adc;../../../../platform/drivers/adc/common;../../../../platform/drivers/can;../../../../platform/drivers/can/common;../../../../platform/drivers/edma;../../../../platform/drivers/edma/common;../../../../platform/drivers/dac;../../../../platform/drivers/dac/common;../../../../platform/drivers/dspi/dspi_master;../../../../platform/drivers/dspi/dspi_slave;../../../../platform/drivers/dspi/common;../../../../platform/drivers/enet;../../../../platform/drivers/enet/common;../../../../platform/drivers/enet/src;../../../../platform/drivers/flash;../../../../platform/drivers/flextimer;../../../../platform/drivers/flextimer/common;../../../../platform/drivers/gpio;../../../../platform/drivers/gpio/common;../../../../platform/drivers/i2c/i2c_master;../../../../platform/drivers/i2c/i2c_slave;../../../../platform/drivers/i2c/common;../../../../platform/drivers/lptmr;../../../../platform/drivers/lptmr/common;../../../../platform/drivers/mmcau;../../../../platform/drivers/pdb;../../../../platform/drivers/pdb/common;../../../../platform/drivers/pit;../../../../platform/drivers/pit/common;../../../../platform/drivers/rtc;../../../../platform/drivers/rtc/common;../../../../platform/drivers/sai;../../../../platform/drivers/sai/common;../../../../platform/drivers/sdhc;../../../../platform/drivers/sdhc/common;../../../../platform/drivers/sdcard;../../../../platform/drivers/soundcard;../../../../platform/drivers/spi;../../../../platform/drivers/spi/common;../../../../platform/drivers/uart;../../../../platform/drivers/uart/common;../../../../platform/drivers/wdog;../../../../platform/drivers/wdog/common;../../../../platform/system/clock;../../../../platform/system/hwtimer;../../../../platform/system/interrupt;../../../../platform/system/power;../../../../boards/common;../../../../boards/common/wm8960;../../../../boards/common/wm8960/src;../../../../platform/drivers/soundcard;../../../../platform/drivers/soundcard/src;../../../../boards/mapsk64
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: ../../../../platform/linker/arm/K64F12/K64FN1Mxxx12_flash.scf
  link misc: ../../../../lib/ksdk_platform_lib/uv4/K64F12/debug/ksdk_platform_lib.lib 
../../../../platform/CMSIS/Lib/ARM/arm_cortexM4lf_math.lib 
--remove
  group utilities
    ../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c
    ../../../../platform/utilities/: fsl_debug_console.h
  group startup
    ../../../../platform/startup/MK64F12/arm/: startup_MK64F12.s
    ../../../../platform/startup/MK64F12/: system_MK64F12.c
    ../../../../platform/startup/: startup.c startup.h
  group source
    ../../src/: main.c audio.c audio.h equalizer.c equalizer.h pcm_data.h terminal_menu.c terminal_menu.h
  group codec
    ../../../../boards/common/wm8960/src/: fsl_wm8960_driver.c
    ../../../../boards/common/wm8960/: fsl_wm8960_driver.h
  group soundcard
    ../../../../platform/drivers/soundcard/src/: fsl_soundcard.c
    ../../../../platform/drivers/soundcard/: fsl_soundcard.h
  group interrupt_handlers
    ../../../../platform/drivers/edma/: fsl_edma_irq.c
    ../../../../platform/drivers/i2c/: fsl_i2c_irq.c
    ../../../../platform/drivers/sai/: fsl_sai_irq.c
  group board
    ../../../../boards/mapsk64/: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h hardware_init.c
target sai_demo Release (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  cpu: as above
  output: sai_demo.out
  c flags: Optim=1 wLevel=2
  c define: NDEBUG, ARM_MATH_CM4, CPU_MK64FN1M0VMD12, KEIL, MAPS_K64, MAPS
  c misc: as above
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: as above
  link misc: ../../../../lib/ksdk_platform_lib/uv4/K64F12/release/ksdk_platform_lib.lib 
../../../../platform/CMSIS/Lib/ARM/arm_cortexM4lf_math.lib 
--remove
