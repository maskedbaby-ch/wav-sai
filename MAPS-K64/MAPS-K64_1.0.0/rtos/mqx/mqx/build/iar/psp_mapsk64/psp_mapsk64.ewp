# IAR project psp_mapsk64.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: CPU_MK64FN1M0VMD12=1; FSL_RTOS_MQX=1; MQX_DISABLE_CONFIG_CHECK=1; _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186
  ICCARM.CCIncludePath2: ../../../source/psp/cortex_m/compiler/iar; ../../../../../../platform/CMSIS/Include/device; ../../../../../../platform/CMSIS/Include; ../../../source/psp/cortex_m; ../../../source/psp/cortex_m/cpu; ../../../../config/mcu/mk64f120m; ../../../../config/board/mapsk64; ../../../../config/common; ../../../source/include; ../../../source/nio; ../../../source/nio/src; ../../../source/nio/fs; ../../../source/tad; ../../../../config/mcu/mk64f120m; ../../../../config/board/mapsk64; ../../../../config/common; ../../../source/bsp/K64F12; ../../../source/include; ../../../source/bsp; ../../../source/nio/drivers/nio_dummy; ../../../source/nio/drivers/nio_mem; ../../../source/nio/drivers/nio_null; ../../../source/nio/drivers/nio_pipe; ../../../source/nio/drivers/nio_serial; ../../../source/nio/drivers/nio_tfs; ../../../source/nio/drivers/nio_tty; ../../../../../../boards/common/phyksz8041; ../../../../../../boards/mapsk64; ../../../../../../platform/startup/MK64F12; ../../../../mqx_stdlib/source/include; ../../../../mqx_stdlib/source/stdio; ../../../../../../platform; ../../../../../../platform/CMSIS/Include; ../../../../../../platform/CMSIS/Include/device; ../../../../../../platform/hal/adc; ../../../../../../platform/hal/can; ../../../../../../platform/hal/dac; ../../../../../../platform/hal/dma; ../../../../../../platform/hal/dmamux; ../../../../../../platform/hal/dspi; ../../../../../../platform/hal/edma; ../../../../../../platform/hal/enet; ../../../../../../platform/hal/flextimer; ../../../../../../platform/hal/gpio; ../../../../../../platform/hal/i2c; ../../../../../../platform/hal/llwu; ../../../../../../platform/hal/lptmr; ../../../../../../platform/hal/lpuart; ../../../../../../platform/hal/mcg; ../../../../../../platform/hal/mpu; ../../../../../../platform/hal/osc; ../../../../../../platform/hal/pdb; ../../../../../../platform/hal/pit; ../../../../../../platform/hal/pmc; ../../../../../../platform/hal/port; ../../../../../../platform/hal/rcm; ../../../../../../platform/hal/rtc; ../../../../../../platform/hal/sai; ../../../../../../platform/hal/sdhc; ../../../../../../platform/hal/sim; ../../../../../../platform/hal/smc; ../../../../../../platform/hal/spi; ../../../../../../platform/hal/uart; ../../../../../../platform/hal/wdog; ../../../../../../platform/drivers/adc; ../../../../../../platform/drivers/adc/common; ../../../../../../platform/drivers/can; ../../../../../../platform/drivers/can/common; ../../../../../../platform/drivers/cmp; ../../../../../../platform/drivers/cmp/common; ../../../../../../platform/drivers/dac; ../../../../../../platform/drivers/dac/common; ../../../../../../platform/drivers/dma; ../../../../../../platform/drivers/dma/common; ../../../../../../platform/drivers/dspi/dspi_master; ../../../../../../platform/drivers/dspi/dspi_slave; ../../../../../../platform/drivers/dspi/common; ../../../../../../platform/drivers/edma; ../../../../../../platform/drivers/edma/common; ../../../../../../platform/drivers/enet; ../../../../../../platform/drivers/enet/common; ../../../../../../platform/drivers/flash; ../../../../../../platform/drivers/flextimer; ../../../../../../platform/drivers/flextimer/common; ../../../../../../platform/drivers/gpio; ../../../../../../platform/drivers/gpio/common; ../../../../../../platform/drivers/i2c/i2c_master; ../../../../../../platform/drivers/i2c/i2c_slave; ../../../../../../platform/drivers/i2c/common; ../../../../../../platform/drivers/lptmr; ../../../../../../platform/drivers/lptmr/common; ../../../../../../platform/drivers/lpuart; ../../../../../../platform/drivers/lpuart/common; ../../../../../../platform/drivers/mmcau; ../../../../../../platform/drivers/mpu; ../../../../../../platform/drivers/mpu/common; ../../../../../../platform/drivers/pdb; ../../../../../../platform/drivers/pdb/common; ../../../../../../platform/drivers/pit; ../../../../../../platform/drivers/pit/common; ../../../../../../platform/drivers/rnga; ../../../../../../platform/drivers/rnga/common; ../../../../../../platform/drivers/rtc; ../../../../../../platform/drivers/rtc/common; ../../../../../../platform/drivers/sai; ../../../../../../platform/drivers/sai/common; ../../../../../../platform/drivers/sdcard; ../../../../../../platform/drivers/sdhc; ../../../../../../platform/drivers/sdhc/common; ../../../../../../platform/drivers/soundcard; ../../../../../../platform/drivers/spi; ../../../../../../platform/drivers/spi/common; ../../../../../../platform/drivers/uart; ../../../../../../platform/drivers/uart/common; ../../../../../../platform/drivers/wdog; ../../../../../../platform/drivers/wdog/common; ../../../../../../platform/utilities; ../../../../../../rtos; ../../../../../../platform/osa; ../../../../../../platform/system/interrupt; ../../../../../../platform/system/clock; ../../../../../../platform/system/hwtimer
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: as above
  AARM.AUserIncludes: ../../../source/psp/cortex_m/compiler/iar; ../../../source/psp/cortex_m; ../../../source/psp/cortex_m/core/M4; ../../../../config/mapsk64; ../../../source/include; ../../../../config/common; ../../../../config/mcu/mk64f120m; ../../../../config/board/mapsk64
  postbuild: ../../bat/psp_mapsk64.bat ../../../.. ../../../../lib/mapsk64.iar/debug/psp iar
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MK64FN1M0VMD12=1; FSL_RTOS_MQX=1; MQX_DISABLE_CONFIG_CHECK=1; NDEBUG=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: as above
  postbuild: ../../bat/psp_mapsk64.bat ../../../.. ../../../../lib/mapsk64.iar/release/psp iar
  ILINK.IlinkOutputFile: libgeneric.out
  group PSP Generic/include
    ../../../source/psp/cortex_m/compiler/iar/: asm_mac.h comp.h comp.c kernel_symbols.S
    ../../../source/include/: gen_rev.h eds.h edserial.h edserprv.h eds_prv.h event.h event_prv.h charq.h klog.h log.h log_prv.h lwsem.h lwevent.h lwevent_prv.h lwlog.h lwlog_prv.h lwmem.h lwmem_prv.h lwmsgq.h lwmsgq_prv.h lwtimer.h lwtimer_prv.h mem_prv.h message.h mmu.h mqx.h mqx_cnfg.h mqx_cpudef.h mqx_inc.h mqx_ioc.h mqx_prv.h mqx_str.h mqx_macros.h msg_prv.h mutex.h mutex_prv.h name.h name_prv.h partition.h partition_prv.h pcb.h posix.h queue.h sem.h sem_prv.h timer.h timer_prv.h watchdog.h watchdog_prv.h unicode.h
  group PSP Generic/kernel
    ../../../source/kernel/: event.c idletask.c inittask.c int.c lwsem.c mem.c mqx.c sched.c task.c time.c taskq.c klog.c log.c lwevent.c lwlog.c lwmem.c lwmsgq.c lwtimer.c msg.c msgq.c msgpool.c mutex.c name.c partition.c queue.c sem.c timer.c watchdog.c
  group PSP Generic/nio
    ../../../source/nio/src/: nio.c nio_prv.h errno.c
    ../../../source/nio/: nio.h errno.h ioctl.h fcntl.h
    ../../../source/nio/fs/: fs_supp.c fs_supp.h
  group PSP Generic/string
    ../../../source/string/: strnlen.c str_utos.c unicode.c
  group PSP Generic/tad
    ../../../source/tad/: tad.c tad.h
  group PSP Specific
    ../../../../../../platform/CMSIS/Include/device/: fsl_device_registers.h
    ../../../../../../platform/CMSIS/Include/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
    ../../../source/psp/cortex_m/: types.inc int_gkis.c int_inst.c int_kisr.c int_pvta.c int_unx.c int_vtab.c int_xcpt.c ipsum.c mem_copy.c mem_zero.c psp_dati.c psp_gelms.c psp_hoti.c psp_iinit.c psp_mat1.c psp_mat2.c psp_mat3.c psp_miti.c psp_msti.c psp_mstiq.c psp_nsti.c psp_psti.c psp_seti.c psp_supp.c psp_tiad.c psp_tida.c psp_tihr.c psp_timn.c psp_tims.c psp_tinm.c psp_tins.c psp_tiol.c psp_tipr.c psp_tips.c psp_tise.c psp_tisu.c psp_tius.c psp_tkti.c psp_usti.c sc_irdyq.c stack_bu.c stack_de.c stack_st.c psp.h psp_abi.h psp_comp.h psp_math.h psp_prv.h psp_rev.h psp_supp.h psp_time.h psptypes.h psp_cpu.h psp_cpudef.h cortex.h kinetis_mpu.h cortex.c nvic.c nvic.h kinetis.h
    ../../../source/psp/cortex_m/core/M4/: psp_prv.inc boot.S dispatch.S support.S
    ../../../source/psp/cortex_m/cpu/: kinetis_fcan.h
  group Config Files
    ../../../../config/mcu/mk64f120m/: mqx_sdk_config.h
    ../../../../config/board/mapsk64/: user_config.h
    ../../../../config/common/: small_ram_config.h
