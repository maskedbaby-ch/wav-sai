<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>all</name><member><project>psp_mapsk64</project><configuration>Debug</configuration></member><member><project>psp_mapsk64</project><configuration>Release</configuration></member></batchDefinition><batchDefinition><name>debug</name><member><project>psp_mapsk64</project><configuration>Debug</configuration></member></batchDefinition><batchDefinition><name>release</name><member><project>psp_mapsk64</project><configuration>Release</configuration></member></batchDefinition></batchBuild>
<project><path>$WS_DIR$\psp_mapsk64.ewp</path></project></workspace>
