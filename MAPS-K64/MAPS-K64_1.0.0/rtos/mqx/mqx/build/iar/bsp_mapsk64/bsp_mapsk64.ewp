# IAR project bsp_mapsk64.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: CPU_MK64FN1M0VMD12=1; FSL_RTOS_MQX=1; _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186
  ICCARM.CCIncludePath2: ../../../../config/mcu/mk64f120m; ../../../../config/board/mapsk64; ../../../../config/common; ../../../source/bsp/K64F12; ../../../source/include; ../../../source/bsp; ../../../source/nio/drivers/nio_dummy; ../../../source/nio/drivers/nio_mem; ../../../source/nio/drivers/nio_null; ../../../source/nio/drivers/nio_pipe; ../../../source/nio/drivers/nio_serial; ../../../source/nio/drivers/nio_tfs; ../../../source/nio/drivers/nio_tty; ../../../../../../boards/common/phyksz8041; ../../../../../../boards/mapsk64; ../../../../../../platform/startup/MK64F12; ../../../source/psp/cortex_m/compiler/iar; ../../../../../../platform/CMSIS/Include/device; ../../../../../../platform/CMSIS/Include; ../../../source/psp/cortex_m; ../../../source/psp/cortex_m/cpu; ../../../../config/mcu/mk64f120m; ../../../../config/board/mapsk64; ../../../../config/common; ../../../source/include; ../../../source/nio; ../../../source/nio/src; ../../../source/nio/fs; ../../../source/tad; ../../../../../../platform; ../../../../../../platform/CMSIS/Include; ../../../../../../platform/CMSIS/Include/device; ../../../../../../platform/hal/adc; ../../../../../../platform/hal/can; ../../../../../../platform/hal/dac; ../../../../../../platform/hal/dma; ../../../../../../platform/hal/dmamux; ../../../../../../platform/hal/dspi; ../../../../../../platform/hal/edma; ../../../../../../platform/hal/enet; ../../../../../../platform/hal/flextimer; ../../../../../../platform/hal/gpio; ../../../../../../platform/hal/i2c; ../../../../../../platform/hal/llwu; ../../../../../../platform/hal/lptmr; ../../../../../../platform/hal/lpuart; ../../../../../../platform/hal/mcg; ../../../../../../platform/hal/mpu; ../../../../../../platform/hal/osc; ../../../../../../platform/hal/pdb; ../../../../../../platform/hal/pit; ../../../../../../platform/hal/pmc; ../../../../../../platform/hal/port; ../../../../../../platform/hal/rcm; ../../../../../../platform/hal/rtc; ../../../../../../platform/hal/sai; ../../../../../../platform/hal/sdhc; ../../../../../../platform/hal/sim; ../../../../../../platform/hal/smc; ../../../../../../platform/hal/spi; ../../../../../../platform/hal/uart; ../../../../../../platform/hal/wdog; ../../../../../../platform/drivers/adc; ../../../../../../platform/drivers/adc/common; ../../../../../../platform/drivers/can; ../../../../../../platform/drivers/can/common; ../../../../../../platform/drivers/cmp; ../../../../../../platform/drivers/cmp/common; ../../../../../../platform/drivers/dac; ../../../../../../platform/drivers/dac/common; ../../../../../../platform/drivers/dma; ../../../../../../platform/drivers/dma/common; ../../../../../../platform/drivers/dspi/dspi_master; ../../../../../../platform/drivers/dspi/dspi_slave; ../../../../../../platform/drivers/dspi/common; ../../../../../../platform/drivers/edma; ../../../../../../platform/drivers/edma/common; ../../../../../../platform/drivers/enet; ../../../../../../platform/drivers/enet/common; ../../../../../../platform/drivers/flash; ../../../../../../platform/drivers/flextimer; ../../../../../../platform/drivers/flextimer/common; ../../../../../../platform/drivers/gpio; ../../../../../../platform/drivers/gpio/common; ../../../../../../platform/drivers/i2c/i2c_master; ../../../../../../platform/drivers/i2c/i2c_slave; ../../../../../../platform/drivers/i2c/common; ../../../../../../platform/drivers/lptmr; ../../../../../../platform/drivers/lptmr/common; ../../../../../../platform/drivers/lpuart; ../../../../../../platform/drivers/lpuart/common; ../../../../../../platform/drivers/mmcau; ../../../../../../platform/drivers/mpu; ../../../../../../platform/drivers/mpu/common; ../../../../../../platform/drivers/pdb; ../../../../../../platform/drivers/pdb/common; ../../../../../../platform/drivers/pit; ../../../../../../platform/drivers/pit/common; ../../../../../../platform/drivers/rnga; ../../../../../../platform/drivers/rnga/common; ../../../../../../platform/drivers/rtc; ../../../../../../platform/drivers/rtc/common; ../../../../../../platform/drivers/sai; ../../../../../../platform/drivers/sai/common; ../../../../../../platform/drivers/sdcard; ../../../../../../platform/drivers/sdhc; ../../../../../../platform/drivers/sdhc/common; ../../../../../../platform/drivers/soundcard; ../../../../../../platform/drivers/spi; ../../../../../../platform/drivers/spi/common; ../../../../../../platform/drivers/uart; ../../../../../../platform/drivers/uart/common; ../../../../../../platform/drivers/wdog; ../../../../../../platform/drivers/wdog/common; ../../../../../../platform/utilities; ../../../../../../rtos; ../../../../../../platform/osa; ../../../../../../platform/system/interrupt; ../../../../../../platform/system/clock; ../../../../../../platform/system/hwtimer
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: CPU_MK64FN1M0VMD12=1; FSL_RTOS_MQX=1; _DEBUG=1
  AARM.AUserIncludes: ../../../../config/mcu/mk64f120m; ../../../../config/board/mapsk64; ../../../source/psp/cortex_m/compiler/iar; ../../../source/psp/cortex_m; ../../../source/psp/cortex_m/core/M4; ../../../../config/mapsk64; ../../../source/include; ../../../../config/common
  postbuild: ../../bat/bsp_mapsk64.bat ../../../.. ../../../../lib/mapsk64.iar/debug/bsp iar
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MK64FN1M0VMD12=1; FSL_RTOS_MQX=1; NDEBUG=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: CPU_MK64FN1M0VMD12=1; FSL_RTOS_MQX=1; NDEBUG=1
  postbuild: ../../bat/bsp_mapsk64.bat ../../../.. ../../../../lib/mapsk64.iar/release/bsp iar
  ILINK.IlinkOutputFile: libgeneric.out
  group Config Files
    ../../../../config/mcu/mk64f120m/: mqx_sdk_config.h
    ../../../../config/board/mapsk64/: user_config.h
  group Config Files/Common
    ../../../../config/common/: small_ram_config.h smallest_config.h maximum_config.h verif_enabled_config.h
  group BSP Files
    ../../../source/bsp/K64F12/: bsp_config.h vectors.c
    ../../../source/include/: mqx.h
    ../../../source/bsp/: bsp.h bsp_prv.h init_hardware.c init_bsp.c init_nio_serial.c mqx_init.c mqx_main.c
  group Peripheral NIO Drivers/nio_dummy
    ../../../source/nio/drivers/nio_dummy/src/: nio_dummy.c
    ../../../source/nio/drivers/nio_dummy/: nio_dummy.h
  group Peripheral NIO Drivers/nio_mem
    ../../../source/nio/drivers/nio_mem/src/: nio_mem.c
    ../../../source/nio/drivers/nio_mem/: nio_mem.h
  group Peripheral NIO Drivers/nio_null
    ../../../source/nio/drivers/nio_null/src/: nio_null.c
    ../../../source/nio/drivers/nio_null/: nio_null.h
  group Peripheral NIO Drivers/nio_pipe
    ../../../source/nio/drivers/nio_pipe/src/: nio_pipe.c
    ../../../source/nio/drivers/nio_pipe/: nio_pipe.h
  group Peripheral NIO Drivers/nio_serial
    ../../../../../../platform/drivers/uart/: fsl_uart_irq.c
    ../../../source/nio/drivers/nio_serial/src/: nio_serial.c
    ../../../source/nio/drivers/nio_serial/: nio_serial.h
  group Peripheral NIO Drivers/nio_tfs
    ../../../source/nio/drivers/nio_tfs/src/: nio_tfs.c
    ../../../source/nio/drivers/nio_tfs/: nio_tfs.h
  group Peripheral NIO Drivers/nio_tty
    ../../../source/nio/drivers/nio_tty/src/: nio_tty.c
    ../../../source/nio/drivers/nio_tty/: nio_tty.h
  group KSDK Files
    ../../../../../../boards/mapsk64/: board.h gpio_pins.h gpio_pins.c pin_mux.h pin_mux.c hardware_init.c
    ../../../../../../platform/startup/MK64F12/: system_MK64F12.c system_MK64F12.h
