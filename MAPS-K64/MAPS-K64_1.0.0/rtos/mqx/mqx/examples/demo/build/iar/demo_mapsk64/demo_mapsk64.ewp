# IAR project demo_mapsk64.ewp, settings and files
configuration Int Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 Freescale MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CPU_MK64FN1M0VMD12=1; FSL_RTOS_MQX=1; _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186
  ICCARM.CCIncludePath2: ../../..; ../../../../../../../../boards/mapsk64; ../../../../../../../../platform/CMSIS/Include/device/MK64F12; ../../../../../../../../platform/startup/MK64F12; ../../../../../../../../platform; ../../../../../../../../platform/CMSIS/Include; ../../../../../../../../platform/CMSIS/Include/device; ../../../../../../../../platform/hal/adc; ../../../../../../../../platform/hal/can; ../../../../../../../../platform/hal/dac; ../../../../../../../../platform/hal/dma; ../../../../../../../../platform/hal/dmamux; ../../../../../../../../platform/hal/dspi; ../../../../../../../../platform/hal/edma; ../../../../../../../../platform/hal/enet; ../../../../../../../../platform/hal/flextimer; ../../../../../../../../platform/hal/gpio; ../../../../../../../../platform/hal/i2c; ../../../../../../../../platform/hal/llwu; ../../../../../../../../platform/hal/lptmr; ../../../../../../../../platform/hal/lpuart; ../../../../../../../../platform/hal/mcg; ../../../../../../../../platform/hal/mpu; ../../../../../../../../platform/hal/osc; ../../../../../../../../platform/hal/pdb; ../../../../../../../../platform/hal/pit; ../../../../../../../../platform/hal/pmc; ../../../../../../../../platform/hal/port; ../../../../../../../../platform/hal/rcm; ../../../../../../../../platform/hal/rtc; ../../../../../../../../platform/hal/sai; ../../../../../../../../platform/hal/sdhc; ../../../../../../../../platform/hal/sim; ../../../../../../../../platform/hal/smc; ../../../../../../../../platform/hal/spi; ../../../../../../../../platform/hal/uart; ../../../../../../../../platform/hal/wdog; ../../../../../../../../platform/drivers/adc; ../../../../../../../../platform/drivers/adc/common; ../../../../../../../../platform/drivers/can; ../../../../../../../../platform/drivers/can/common; ../../../../../../../../platform/drivers/cmp; ../../../../../../../../platform/drivers/cmp/common; ../../../../../../../../platform/drivers/dac; ../../../../../../../../platform/drivers/dac/common; ../../../../../../../../platform/drivers/dma; ../../../../../../../../platform/drivers/dma/common; ../../../../../../../../platform/drivers/dspi/dspi_master; ../../../../../../../../platform/drivers/dspi/dspi_slave; ../../../../../../../../platform/drivers/dspi/common; ../../../../../../../../platform/drivers/edma; ../../../../../../../../platform/drivers/edma/common; ../../../../../../../../platform/drivers/enet; ../../../../../../../../platform/drivers/enet/common; ../../../../../../../../platform/drivers/flash; ../../../../../../../../platform/drivers/flextimer; ../../../../../../../../platform/drivers/flextimer/common; ../../../../../../../../platform/drivers/gpio; ../../../../../../../../platform/drivers/gpio/common; ../../../../../../../../platform/drivers/i2c/i2c_master; ../../../../../../../../platform/drivers/i2c/i2c_slave; ../../../../../../../../platform/drivers/i2c/common; ../../../../../../../../platform/drivers/lptmr; ../../../../../../../../platform/drivers/lptmr/common; ../../../../../../../../platform/drivers/lpuart; ../../../../../../../../platform/drivers/lpuart/common; ../../../../../../../../platform/drivers/mmcau; ../../../../../../../../platform/drivers/mpu; ../../../../../../../../platform/drivers/mpu/common; ../../../../../../../../platform/drivers/pdb; ../../../../../../../../platform/drivers/pdb/common; ../../../../../../../../platform/drivers/pit; ../../../../../../../../platform/drivers/pit/common; ../../../../../../../../platform/drivers/rnga; ../../../../../../../../platform/drivers/rnga/common; ../../../../../../../../platform/drivers/rtc; ../../../../../../../../platform/drivers/rtc/common; ../../../../../../../../platform/drivers/sai; ../../../../../../../../platform/drivers/sai/common; ../../../../../../../../platform/drivers/sdcard; ../../../../../../../../platform/drivers/sdhc; ../../../../../../../../platform/drivers/sdhc/common; ../../../../../../../../platform/drivers/soundcard; ../../../../../../../../platform/drivers/spi; ../../../../../../../../platform/drivers/spi/common; ../../../../../../../../platform/drivers/uart; ../../../../../../../../platform/drivers/uart/common; ../../../../../../../../platform/drivers/wdog; ../../../../../../../../platform/drivers/wdog/common; ../../../../../../../../platform/utilities; ../../../../../../../../rtos; ../../../../../../../../platform/osa; ../../../../../../../../platform/system/interrupt; ../../../../../../../../platform/system/clock; ../../../../../../../../platform/system/hwtimer; ../../../../../../lib/mapsk64.iar/debug/config; ../../../../../../lib/mapsk64.iar/debug/bsp; ../../../../../../lib/mapsk64.iar/debug/psp; ../../../../../../lib/mapsk64.iar/debug/mqx_stdlib
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: CPU_MK64FN1M0VMD12=1; FSL_RTOS_MQX=1; _DEBUG=1
  AARM.AUserIncludes: ../../../../../../../../boards/mapsk64; ../../../../../../../../platform/CMSIS/Include/device/MK64F12; ../../../../../../../../platform/startup/MK64F12; ../../../../../../lib/mapsk64.iar/debug/config; ../../../../../../lib/mapsk64.iar/debug/bsp; ../../../../../../lib/mapsk64.iar/debug/psp; ../../../../../../lib/mapsk64.iar/debug/mqx_stdlib
  OBJCOPY.OOCOutputFile: app.srec
  ILINK.IlinkOutputFile: demo.out
  ILINK.IlinkIcfFile: ../../../../../../lib/mapsk64.iar/debug/bsp/K64FN1Mxxx12_flash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../../../../lib/ksdk_mqx_lib/iar/K64F12/debug/ksdk_mqx_lib.a; ../../../../../../lib/mapsk64.iar/debug/mqx_stdlib/mqx_stdlib.a; ../../../../../../lib/mapsk64.iar/debug/bsp/bsp.a; ../../../../../../lib/mapsk64.iar/debug/psp/psp.a
  ILINK.IlinkProgramEntryLabel: __boot
configuration Int Flash Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MK64FN1M0VMD12=1; FSL_RTOS_MQX=1; NDEBUG=1
  ICCARM.CCIncludePath2: ../../..; ../../../../../../../../boards/mapsk64; ../../../../../../../../platform/CMSIS/Include/device/MK64F12; ../../../../../../../../platform/startup/MK64F12; ../../../../../../../../platform; ../../../../../../../../platform/CMSIS/Include; ../../../../../../../../platform/CMSIS/Include/device; ../../../../../../../../platform/hal/adc; ../../../../../../../../platform/hal/can; ../../../../../../../../platform/hal/dac; ../../../../../../../../platform/hal/dma; ../../../../../../../../platform/hal/dmamux; ../../../../../../../../platform/hal/dspi; ../../../../../../../../platform/hal/edma; ../../../../../../../../platform/hal/enet; ../../../../../../../../platform/hal/flextimer; ../../../../../../../../platform/hal/gpio; ../../../../../../../../platform/hal/i2c; ../../../../../../../../platform/hal/llwu; ../../../../../../../../platform/hal/lptmr; ../../../../../../../../platform/hal/lpuart; ../../../../../../../../platform/hal/mcg; ../../../../../../../../platform/hal/mpu; ../../../../../../../../platform/hal/osc; ../../../../../../../../platform/hal/pdb; ../../../../../../../../platform/hal/pit; ../../../../../../../../platform/hal/pmc; ../../../../../../../../platform/hal/port; ../../../../../../../../platform/hal/rcm; ../../../../../../../../platform/hal/rtc; ../../../../../../../../platform/hal/sai; ../../../../../../../../platform/hal/sdhc; ../../../../../../../../platform/hal/sim; ../../../../../../../../platform/hal/smc; ../../../../../../../../platform/hal/spi; ../../../../../../../../platform/hal/uart; ../../../../../../../../platform/hal/wdog; ../../../../../../../../platform/drivers/adc; ../../../../../../../../platform/drivers/adc/common; ../../../../../../../../platform/drivers/can; ../../../../../../../../platform/drivers/can/common; ../../../../../../../../platform/drivers/cmp; ../../../../../../../../platform/drivers/cmp/common; ../../../../../../../../platform/drivers/dac; ../../../../../../../../platform/drivers/dac/common; ../../../../../../../../platform/drivers/dma; ../../../../../../../../platform/drivers/dma/common; ../../../../../../../../platform/drivers/dspi/dspi_master; ../../../../../../../../platform/drivers/dspi/dspi_slave; ../../../../../../../../platform/drivers/dspi/common; ../../../../../../../../platform/drivers/edma; ../../../../../../../../platform/drivers/edma/common; ../../../../../../../../platform/drivers/enet; ../../../../../../../../platform/drivers/enet/common; ../../../../../../../../platform/drivers/flash; ../../../../../../../../platform/drivers/flextimer; ../../../../../../../../platform/drivers/flextimer/common; ../../../../../../../../platform/drivers/gpio; ../../../../../../../../platform/drivers/gpio/common; ../../../../../../../../platform/drivers/i2c/i2c_master; ../../../../../../../../platform/drivers/i2c/i2c_slave; ../../../../../../../../platform/drivers/i2c/common; ../../../../../../../../platform/drivers/lptmr; ../../../../../../../../platform/drivers/lptmr/common; ../../../../../../../../platform/drivers/lpuart; ../../../../../../../../platform/drivers/lpuart/common; ../../../../../../../../platform/drivers/mmcau; ../../../../../../../../platform/drivers/mpu; ../../../../../../../../platform/drivers/mpu/common; ../../../../../../../../platform/drivers/pdb; ../../../../../../../../platform/drivers/pdb/common; ../../../../../../../../platform/drivers/pit; ../../../../../../../../platform/drivers/pit/common; ../../../../../../../../platform/drivers/rnga; ../../../../../../../../platform/drivers/rnga/common; ../../../../../../../../platform/drivers/rtc; ../../../../../../../../platform/drivers/rtc/common; ../../../../../../../../platform/drivers/sai; ../../../../../../../../platform/drivers/sai/common; ../../../../../../../../platform/drivers/sdcard; ../../../../../../../../platform/drivers/sdhc; ../../../../../../../../platform/drivers/sdhc/common; ../../../../../../../../platform/drivers/soundcard; ../../../../../../../../platform/drivers/spi; ../../../../../../../../platform/drivers/spi/common; ../../../../../../../../platform/drivers/uart; ../../../../../../../../platform/drivers/uart/common; ../../../../../../../../platform/drivers/wdog; ../../../../../../../../platform/drivers/wdog/common; ../../../../../../../../platform/utilities; ../../../../../../../../rtos; ../../../../../../../../platform/osa; ../../../../../../../../platform/system/interrupt; ../../../../../../../../platform/system/clock; ../../../../../../../../platform/system/hwtimer; ../../../../../../lib/mapsk64.iar/release/config; ../../../../../../lib/mapsk64.iar/release/bsp; ../../../../../../lib/mapsk64.iar/release/psp; ../../../../../../lib/mapsk64.iar/release/mqx_stdlib
  ICCARM.CCOptLevel: 3
  AARM.ADefines: CPU_MK64FN1M0VMD12=1; FSL_RTOS_MQX=1; NDEBUG=1
  AARM.AUserIncludes: ../../../../../../../../boards/mapsk64; ../../../../../../../../platform/CMSIS/Include/device/MK64F12; ../../../../../../../../platform/startup/MK64F12; ../../../../../../lib/mapsk64.iar/release/config; ../../../../../../lib/mapsk64.iar/release/bsp; ../../../../../../lib/mapsk64.iar/release/psp; ../../../../../../lib/mapsk64.iar/release/mqx_stdlib
  ILINK.IlinkIcfFile: ../../../../../../lib/mapsk64.iar/release/bsp/K64FN1Mxxx12_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../../lib/ksdk_mqx_lib/iar/K64F12/release/ksdk_mqx_lib.a; ../../../../../../lib/mapsk64.iar/release/mqx_stdlib/mqx_stdlib.a; ../../../../../../lib/mapsk64.iar/release/bsp/bsp.a; ../../../../../../lib/mapsk64.iar/release/psp/psp.a
  group Sources
    ../../../: ttl.c sender.c semb.c sema.c responde.c mutexb.c mutexa.c main.c eventb.c eventa.c demo.h demo.dsn demo.c btimesli.c atimesli.c
