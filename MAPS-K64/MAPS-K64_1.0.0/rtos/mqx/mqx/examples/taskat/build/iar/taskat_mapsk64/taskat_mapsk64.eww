<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>all</name><member><project>taskat_mapsk64</project><configuration>Int Flash Debug</configuration></member><member><project>taskat_mapsk64</project><configuration>Int Flash Release</configuration></member><member><project>bsp_mapsk64</project><configuration>Debug</configuration></member><member><project>bsp_mapsk64</project><configuration>Release</configuration></member><member><project>psp_mapsk64</project><configuration>Debug</configuration></member><member><project>psp_mapsk64</project><configuration>Release</configuration></member><member><project>mqx_stdlib_mapsk64</project><configuration>Debug</configuration></member><member><project>mqx_stdlib_mapsk64</project><configuration>Release</configuration></member></batchDefinition><batchDefinition><name>int flash debug</name><member><project>taskat_mapsk64</project><configuration>Int Flash Debug</configuration></member></batchDefinition><batchDefinition><name>int flash release</name><member><project>taskat_mapsk64</project><configuration>Int Flash Release</configuration></member></batchDefinition><batchDefinition><name>debug</name><member><project>bsp_mapsk64</project><configuration>Debug</configuration></member><member><project>psp_mapsk64</project><configuration>Debug</configuration></member><member><project>mqx_stdlib_mapsk64</project><configuration>Debug</configuration></member></batchDefinition><batchDefinition><name>release</name><member><project>bsp_mapsk64</project><configuration>Release</configuration></member><member><project>psp_mapsk64</project><configuration>Release</configuration></member><member><project>mqx_stdlib_mapsk64</project><configuration>Release</configuration></member></batchDefinition></batchBuild>
<project><path>$WS_DIR$\taskat_mapsk64.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\build\iar\bsp_mapsk64\bsp_mapsk64.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\build\iar\psp_mapsk64\psp_mapsk64.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\..\mqx_stdlib\build\iar\mqx_stdlib_mapsk64\mqx_stdlib_mapsk64.ewp</path></project></workspace>
