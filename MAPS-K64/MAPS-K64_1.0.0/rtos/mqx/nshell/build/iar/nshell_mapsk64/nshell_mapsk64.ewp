# IAR project nshell_mapsk64.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: CPU_MK64FN1M0VMD12=1; FSL_RTOS_MQX=1; _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186
  ICCARM.CCIncludePath2: ../../../source/include; ../../../source/include; ../../../../config/mcu/mk64f120m; ../../../../config/board/mapsk64; ../../../../config/common; ../../../../mqx/source/bsp/K64F12; ../../../../mqx/source/include; ../../../../mqx/source/bsp; ../../../../mqx/source/nio/drivers/nio_dummy; ../../../../mqx/source/nio/drivers/nio_mem; ../../../../mqx/source/nio/drivers/nio_null; ../../../../mqx/source/nio/drivers/nio_pipe; ../../../../mqx/source/nio/drivers/nio_serial; ../../../../mqx/source/nio/drivers/nio_tfs; ../../../../mqx/source/nio/drivers/nio_tty; ../../../../../../boards/common/phyksz8041; ../../../../../../boards/mapsk64; ../../../../../../platform/startup/MK64F12; ../../../../mqx/source/psp/cortex_m/compiler/iar; ../../../../../../platform/CMSIS/Include/device; ../../../../../../platform/CMSIS/Include; ../../../../mqx/source/psp/cortex_m; ../../../../mqx/source/psp/cortex_m/cpu; ../../../../config/mcu/mk64f120m; ../../../../config/board/mapsk64; ../../../../config/common; ../../../../mqx/source/include; ../../../../mqx/source/nio; ../../../../mqx/source/nio/src; ../../../../mqx/source/nio/fs; ../../../../mqx/source/tad; ../../../../mqx_stdlib/source/include; ../../../../mqx_stdlib/source/stdio; ../../../../../../platform; ../../../../../../platform/CMSIS/Include; ../../../../../../platform/CMSIS/Include/device; ../../../../../../platform/hal/adc; ../../../../../../platform/hal/can; ../../../../../../platform/hal/dac; ../../../../../../platform/hal/dma; ../../../../../../platform/hal/dmamux; ../../../../../../platform/hal/dspi; ../../../../../../platform/hal/edma; ../../../../../../platform/hal/enet; ../../../../../../platform/hal/flextimer; ../../../../../../platform/hal/gpio; ../../../../../../platform/hal/i2c; ../../../../../../platform/hal/llwu; ../../../../../../platform/hal/lptmr; ../../../../../../platform/hal/lpuart; ../../../../../../platform/hal/mcg; ../../../../../../platform/hal/mpu; ../../../../../../platform/hal/osc; ../../../../../../platform/hal/pdb; ../../../../../../platform/hal/pit; ../../../../../../platform/hal/pmc; ../../../../../../platform/hal/port; ../../../../../../platform/hal/rcm; ../../../../../../platform/hal/rtc; ../../../../../../platform/hal/sai; ../../../../../../platform/hal/sdhc; ../../../../../../platform/hal/sim; ../../../../../../platform/hal/smc; ../../../../../../platform/hal/spi; ../../../../../../platform/hal/uart; ../../../../../../platform/hal/wdog; ../../../../../../platform/drivers/adc; ../../../../../../platform/drivers/adc/common; ../../../../../../platform/drivers/can; ../../../../../../platform/drivers/can/common; ../../../../../../platform/drivers/cmp; ../../../../../../platform/drivers/cmp/common; ../../../../../../platform/drivers/dac; ../../../../../../platform/drivers/dac/common; ../../../../../../platform/drivers/dma; ../../../../../../platform/drivers/dma/common; ../../../../../../platform/drivers/dspi/dspi_master; ../../../../../../platform/drivers/dspi/dspi_slave; ../../../../../../platform/drivers/dspi/common; ../../../../../../platform/drivers/edma; ../../../../../../platform/drivers/edma/common; ../../../../../../platform/drivers/enet; ../../../../../../platform/drivers/enet/common; ../../../../../../platform/drivers/flash; ../../../../../../platform/drivers/flextimer; ../../../../../../platform/drivers/flextimer/common; ../../../../../../platform/drivers/gpio; ../../../../../../platform/drivers/gpio/common; ../../../../../../platform/drivers/i2c/i2c_master; ../../../../../../platform/drivers/i2c/i2c_slave; ../../../../../../platform/drivers/i2c/common; ../../../../../../platform/drivers/lptmr; ../../../../../../platform/drivers/lptmr/common; ../../../../../../platform/drivers/lpuart; ../../../../../../platform/drivers/lpuart/common; ../../../../../../platform/drivers/mmcau; ../../../../../../platform/drivers/mpu; ../../../../../../platform/drivers/mpu/common; ../../../../../../platform/drivers/pdb; ../../../../../../platform/drivers/pdb/common; ../../../../../../platform/drivers/pit; ../../../../../../platform/drivers/pit/common; ../../../../../../platform/drivers/rnga; ../../../../../../platform/drivers/rnga/common; ../../../../../../platform/drivers/rtc; ../../../../../../platform/drivers/rtc/common; ../../../../../../platform/drivers/sai; ../../../../../../platform/drivers/sai/common; ../../../../../../platform/drivers/sdcard; ../../../../../../platform/drivers/sdhc; ../../../../../../platform/drivers/sdhc/common; ../../../../../../platform/drivers/soundcard; ../../../../../../platform/drivers/spi; ../../../../../../platform/drivers/spi/common; ../../../../../../platform/drivers/uart; ../../../../../../platform/drivers/uart/common; ../../../../../../platform/drivers/wdog; ../../../../../../platform/drivers/wdog/common; ../../../../../../platform/utilities; ../../../../../../rtos; ../../../../../../platform/osa; ../../../../../../platform/system/interrupt; ../../../../../../platform/system/clock; ../../../../../../platform/system/hwtimer
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: CPU_MK64FN1M0VMD12=1; FSL_RTOS_MQX=1; _DEBUG=1
  AARM.AUserIncludes: ../../../../config/mcu/mk64f120m; ../../../../config/board/mapsk64; ../../../../mqx/source/psp/cortex_m/compiler/iar; ../../../../mqx/source/psp/cortex_m; ../../../../mqx/source/psp/cortex_m/core/M4; ../../../../config/mapsk64; ../../../../mqx/source/include; ../../../../config/common
  postbuild: ../../bat/nshell_mapsk64.bat ../../../.. ../../../../lib/mapsk64.iar/debug/nshell iar
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MK64FN1M0VMD12=1; FSL_RTOS_MQX=1; NDEBUG=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: CPU_MK64FN1M0VMD12=1; FSL_RTOS_MQX=1; NDEBUG=1
  postbuild: ../../bat/nshell_mapsk64.bat ../../../.. ../../../../lib/mapsk64.iar/release/nshell iar
  ILINK.IlinkOutputFile: libgeneric.out
  group Shell Source/mqx
    ../../../source/mqx/: sh_abort.c sh_kill.c sh_pause.c sh_tad.c
    ../../../source/include/: sh_prv.h shell.h
  group Shell Source/shell
    ../../../source/shell/: sh_cmdlist.c sh_exit.c sh_help.c sh_sh.c sh_util.c shell.c
    ../../../source/include/: sh_rtcs.h sh_enet.h
