# IAR project mqx_stdlib_mapsk64.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: CPU_MK64FN1M0VMD12=1; FSL_RTOS_MQX=1; _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186
  ICCARM.CCIncludePath2: ../../../source/include; ../../../source/stdio; ../../../../../../platform; ../../../../../../platform/CMSIS/Include; ../../../../../../platform/CMSIS/Include/device; ../../../../../../platform/hal/adc; ../../../../../../platform/hal/can; ../../../../../../platform/hal/dac; ../../../../../../platform/hal/dma; ../../../../../../platform/hal/dmamux; ../../../../../../platform/hal/dspi; ../../../../../../platform/hal/edma; ../../../../../../platform/hal/enet; ../../../../../../platform/hal/flextimer; ../../../../../../platform/hal/gpio; ../../../../../../platform/hal/i2c; ../../../../../../platform/hal/llwu; ../../../../../../platform/hal/lptmr; ../../../../../../platform/hal/lpuart; ../../../../../../platform/hal/mcg; ../../../../../../platform/hal/mpu; ../../../../../../platform/hal/osc; ../../../../../../platform/hal/pdb; ../../../../../../platform/hal/pit; ../../../../../../platform/hal/pmc; ../../../../../../platform/hal/port; ../../../../../../platform/hal/rcm; ../../../../../../platform/hal/rtc; ../../../../../../platform/hal/sai; ../../../../../../platform/hal/sdhc; ../../../../../../platform/hal/sim; ../../../../../../platform/hal/smc; ../../../../../../platform/hal/spi; ../../../../../../platform/hal/uart; ../../../../../../platform/hal/wdog; ../../../../../../platform/drivers/adc; ../../../../../../platform/drivers/adc/common; ../../../../../../platform/drivers/can; ../../../../../../platform/drivers/can/common; ../../../../../../platform/drivers/cmp; ../../../../../../platform/drivers/cmp/common; ../../../../../../platform/drivers/dac; ../../../../../../platform/drivers/dac/common; ../../../../../../platform/drivers/dma; ../../../../../../platform/drivers/dma/common; ../../../../../../platform/drivers/dspi/dspi_master; ../../../../../../platform/drivers/dspi/dspi_slave; ../../../../../../platform/drivers/dspi/common; ../../../../../../platform/drivers/edma; ../../../../../../platform/drivers/edma/common; ../../../../../../platform/drivers/enet; ../../../../../../platform/drivers/enet/common; ../../../../../../platform/drivers/flash; ../../../../../../platform/drivers/flextimer; ../../../../../../platform/drivers/flextimer/common; ../../../../../../platform/drivers/gpio; ../../../../../../platform/drivers/gpio/common; ../../../../../../platform/drivers/i2c/i2c_master; ../../../../../../platform/drivers/i2c/i2c_slave; ../../../../../../platform/drivers/i2c/common; ../../../../../../platform/drivers/lptmr; ../../../../../../platform/drivers/lptmr/common; ../../../../../../platform/drivers/lpuart; ../../../../../../platform/drivers/lpuart/common; ../../../../../../platform/drivers/mmcau; ../../../../../../platform/drivers/mpu; ../../../../../../platform/drivers/mpu/common; ../../../../../../platform/drivers/pdb; ../../../../../../platform/drivers/pdb/common; ../../../../../../platform/drivers/pit; ../../../../../../platform/drivers/pit/common; ../../../../../../platform/drivers/rnga; ../../../../../../platform/drivers/rnga/common; ../../../../../../platform/drivers/rtc; ../../../../../../platform/drivers/rtc/common; ../../../../../../platform/drivers/sai; ../../../../../../platform/drivers/sai/common; ../../../../../../platform/drivers/sdcard; ../../../../../../platform/drivers/sdhc; ../../../../../../platform/drivers/sdhc/common; ../../../../../../platform/drivers/soundcard; ../../../../../../platform/drivers/spi; ../../../../../../platform/drivers/spi/common; ../../../../../../platform/drivers/uart; ../../../../../../platform/drivers/uart/common; ../../../../../../platform/drivers/wdog; ../../../../../../platform/drivers/wdog/common; ../../../../../../platform/utilities; ../../../../../../rtos; ../../../../../../platform/osa; ../../../../../../platform/system/interrupt; ../../../../../../platform/system/clock; ../../../../../../platform/system/hwtimer
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: CPU_MK64FN1M0VMD12=1; FSL_RTOS_MQX=1; _DEBUG=1
  postbuild: ../../bat/mqx_stdlib_mapsk64.bat ../../../.. ../../../../lib/mapsk64.iar/debug/mqx_stdlib iar
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MK64FN1M0VMD12=1; FSL_RTOS_MQX=1; NDEBUG=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: CPU_MK64FN1M0VMD12=1; FSL_RTOS_MQX=1; NDEBUG=1
  postbuild: ../../bat/mqx_stdlib_mapsk64.bat ../../../.. ../../../../lib/mapsk64.iar/release/mqx_stdlib iar
  ILINK.IlinkOutputFile: libgeneric.out
  group mqx_stdlib Source/include
    ../../../source/include/: std_prv.h stdio.h strings.h
  group mqx_stdlib Source/mqx_stdio
    ../../../source/stdio/: buf_prv.c buf_prv.h err.c fclose.c fflush.c fopen.c fp_prv.c fp_prv.h fread.c fwrite.c get.c pos.c print.c print_prv.c print_prv.h put.c scan.c scan_prv.c scan_prv.h stdio.c
  group mqx_stdlib Source/mqx_strings
    ../../../source/strings/: strings.c
