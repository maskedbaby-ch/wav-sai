<?xml version="1.0" encoding="UTF-8" standalone="no"?>
<ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd">
  <SchemaVersion>1.0</SchemaVersion>
  <Header>### uVision Project, (C) Keil Software</Header>
  <WorkspaceName>WorkSpace</WorkspaceName>
<project><PathAndName>..\..\..\mqx\examples\demo\build\uv4\demo_mapsk64\demo_mapsk64.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\event\build\uv4\event_mapsk64\event_mapsk64.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\hello\build\uv4\hello_mapsk64\hello_mapsk64.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\isr\build\uv4\isr_mapsk64\isr_mapsk64.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\klog\build\uv4\klog_mapsk64\klog_mapsk64.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\log\build\uv4\log_mapsk64\log_mapsk64.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\lwdemo\build\uv4\lwdemo_mapsk64\lwdemo_mapsk64.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\lwevent\build\uv4\lwevent_mapsk64\lwevent_mapsk64.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\lwlog\build\uv4\lwlog_mapsk64\lwlog_mapsk64.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\lwmsgq\build\uv4\lwmsgq_mapsk64\lwmsgq_mapsk64.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\lwsem\build\uv4\lwsem_mapsk64\lwsem_mapsk64.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\msg\build\uv4\msg_mapsk64\msg_mapsk64.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\mutex\build\uv4\mutex_mapsk64\mutex_mapsk64.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\nill\build\uv4\nill_mapsk64\nill_mapsk64.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\sem\build\uv4\sem_mapsk64\sem_mapsk64.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\taskat\build\uv4\taskat_mapsk64\taskat_mapsk64.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\taskq\build\uv4\taskq_mapsk64\taskq_mapsk64.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\test\build\uv4\test_mapsk64\test_mapsk64.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\timer\build\uv4\timer_mapsk64\timer_mapsk64.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\watchdog\build\uv4\watchdog_mapsk64\watchdog_mapsk64.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples_osa\event\build\uv4\event_mapsk64\osa_event_mapsk64.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples_osa\hello\build\uv4\hello_mapsk64\osa_hello_mapsk64.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples_osa\hwtimer\build\uv4\hwtimer_mapsk64\osa_hwtimer_mapsk64.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples_osa\msgq\build\uv4\msgq_mapsk64\osa_msgq_mapsk64.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples_osa\mutex\build\uv4\mutex_mapsk64\osa_mutex_mapsk64.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples_osa\semaphore\build\uv4\semaphore_mapsk64\osa_semaphore_mapsk64.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project></ProjectWorkspace>
