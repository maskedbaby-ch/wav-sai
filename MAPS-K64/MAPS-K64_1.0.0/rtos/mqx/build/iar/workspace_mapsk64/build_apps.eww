<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>all</name><member><project>demo</project><configuration>Int Flash Debug</configuration></member><member><project>demo</project><configuration>Int Flash Release</configuration></member><member><project>event</project><configuration>Int Flash Debug</configuration></member><member><project>event</project><configuration>Int Flash Release</configuration></member><member><project>hello</project><configuration>Int Flash Debug</configuration></member><member><project>hello</project><configuration>Int Flash Release</configuration></member><member><project>isr</project><configuration>Int Flash Debug</configuration></member><member><project>isr</project><configuration>Int Flash Release</configuration></member><member><project>klog</project><configuration>Int Flash Debug</configuration></member><member><project>klog</project><configuration>Int Flash Release</configuration></member><member><project>log</project><configuration>Int Flash Debug</configuration></member><member><project>log</project><configuration>Int Flash Release</configuration></member><member><project>lwdemo</project><configuration>Int Flash Debug</configuration></member><member><project>lwdemo</project><configuration>Int Flash Release</configuration></member><member><project>lwevent</project><configuration>Int Flash Debug</configuration></member><member><project>lwevent</project><configuration>Int Flash Release</configuration></member><member><project>lwlog</project><configuration>Int Flash Debug</configuration></member><member><project>lwlog</project><configuration>Int Flash Release</configuration></member><member><project>lwmsgq</project><configuration>Int Flash Debug</configuration></member><member><project>lwmsgq</project><configuration>Int Flash Release</configuration></member><member><project>lwsem</project><configuration>Int Flash Debug</configuration></member><member><project>lwsem</project><configuration>Int Flash Release</configuration></member><member><project>msg</project><configuration>Int Flash Debug</configuration></member><member><project>msg</project><configuration>Int Flash Release</configuration></member><member><project>mutex</project><configuration>Int Flash Debug</configuration></member><member><project>mutex</project><configuration>Int Flash Release</configuration></member><member><project>nill</project><configuration>Int Flash Debug</configuration></member><member><project>nill</project><configuration>Int Flash Release</configuration></member><member><project>sem</project><configuration>Int Flash Debug</configuration></member><member><project>sem</project><configuration>Int Flash Release</configuration></member><member><project>taskat</project><configuration>Int Flash Debug</configuration></member><member><project>taskat</project><configuration>Int Flash Release</configuration></member><member><project>taskq</project><configuration>Int Flash Debug</configuration></member><member><project>taskq</project><configuration>Int Flash Release</configuration></member><member><project>test</project><configuration>Int Flash Debug</configuration></member><member><project>test</project><configuration>Int Flash Release</configuration></member><member><project>timer</project><configuration>Int Flash Debug</configuration></member><member><project>timer</project><configuration>Int Flash Release</configuration></member><member><project>watchdog</project><configuration>Int Flash Debug</configuration></member><member><project>watchdog</project><configuration>Int Flash Release</configuration></member><member><project>osa_event</project><configuration>Int Flash Debug</configuration></member><member><project>osa_event</project><configuration>Int Flash Release</configuration></member><member><project>osa_hello</project><configuration>Int Flash Debug</configuration></member><member><project>osa_hello</project><configuration>Int Flash Release</configuration></member><member><project>osa_hwtimer</project><configuration>Int Flash Debug</configuration></member><member><project>osa_hwtimer</project><configuration>Int Flash Release</configuration></member><member><project>osa_msgq</project><configuration>Int Flash Debug</configuration></member><member><project>osa_msgq</project><configuration>Int Flash Release</configuration></member><member><project>osa_mutex</project><configuration>Int Flash Debug</configuration></member><member><project>osa_mutex</project><configuration>Int Flash Release</configuration></member><member><project>osa_semaphore</project><configuration>Int Flash Debug</configuration></member><member><project>osa_semaphore</project><configuration>Int Flash Release</configuration></member></batchDefinition><batchDefinition><name>int flash debug</name><member><project>demo_mapsk64</project><configuration>Int Flash Debug</configuration></member><member><project>event_mapsk64</project><configuration>Int Flash Debug</configuration></member><member><project>hello_mapsk64</project><configuration>Int Flash Debug</configuration></member><member><project>isr_mapsk64</project><configuration>Int Flash Debug</configuration></member><member><project>klog_mapsk64</project><configuration>Int Flash Debug</configuration></member><member><project>log_mapsk64</project><configuration>Int Flash Debug</configuration></member><member><project>lwdemo_mapsk64</project><configuration>Int Flash Debug</configuration></member><member><project>lwevent_mapsk64</project><configuration>Int Flash Debug</configuration></member><member><project>lwlog_mapsk64</project><configuration>Int Flash Debug</configuration></member><member><project>lwmsgq_mapsk64</project><configuration>Int Flash Debug</configuration></member><member><project>lwsem_mapsk64</project><configuration>Int Flash Debug</configuration></member><member><project>msg_mapsk64</project><configuration>Int Flash Debug</configuration></member><member><project>mutex_mapsk64</project><configuration>Int Flash Debug</configuration></member><member><project>nill_mapsk64</project><configuration>Int Flash Debug</configuration></member><member><project>sem_mapsk64</project><configuration>Int Flash Debug</configuration></member><member><project>taskat_mapsk64</project><configuration>Int Flash Debug</configuration></member><member><project>taskq_mapsk64</project><configuration>Int Flash Debug</configuration></member><member><project>test_mapsk64</project><configuration>Int Flash Debug</configuration></member><member><project>timer_mapsk64</project><configuration>Int Flash Debug</configuration></member><member><project>watchdog_mapsk64</project><configuration>Int Flash Debug</configuration></member><member><project>osa_event_mapsk64</project><configuration>Int Flash Debug</configuration></member><member><project>osa_hello_mapsk64</project><configuration>Int Flash Debug</configuration></member><member><project>osa_hwtimer_mapsk64</project><configuration>Int Flash Debug</configuration></member><member><project>osa_msgq_mapsk64</project><configuration>Int Flash Debug</configuration></member><member><project>osa_mutex_mapsk64</project><configuration>Int Flash Debug</configuration></member><member><project>osa_semaphore_mapsk64</project><configuration>Int Flash Debug</configuration></member></batchDefinition><batchDefinition><name>int flash release</name><member><project>demo_mapsk64</project><configuration>Int Flash Release</configuration></member><member><project>event_mapsk64</project><configuration>Int Flash Release</configuration></member><member><project>hello_mapsk64</project><configuration>Int Flash Release</configuration></member><member><project>isr_mapsk64</project><configuration>Int Flash Release</configuration></member><member><project>klog_mapsk64</project><configuration>Int Flash Release</configuration></member><member><project>log_mapsk64</project><configuration>Int Flash Release</configuration></member><member><project>lwdemo_mapsk64</project><configuration>Int Flash Release</configuration></member><member><project>lwevent_mapsk64</project><configuration>Int Flash Release</configuration></member><member><project>lwlog_mapsk64</project><configuration>Int Flash Release</configuration></member><member><project>lwmsgq_mapsk64</project><configuration>Int Flash Release</configuration></member><member><project>lwsem_mapsk64</project><configuration>Int Flash Release</configuration></member><member><project>msg_mapsk64</project><configuration>Int Flash Release</configuration></member><member><project>mutex_mapsk64</project><configuration>Int Flash Release</configuration></member><member><project>nill_mapsk64</project><configuration>Int Flash Release</configuration></member><member><project>sem_mapsk64</project><configuration>Int Flash Release</configuration></member><member><project>taskat_mapsk64</project><configuration>Int Flash Release</configuration></member><member><project>taskq_mapsk64</project><configuration>Int Flash Release</configuration></member><member><project>test_mapsk64</project><configuration>Int Flash Release</configuration></member><member><project>timer_mapsk64</project><configuration>Int Flash Release</configuration></member><member><project>watchdog_mapsk64</project><configuration>Int Flash Release</configuration></member><member><project>osa_event_mapsk64</project><configuration>Int Flash Release</configuration></member><member><project>osa_hello_mapsk64</project><configuration>Int Flash Release</configuration></member><member><project>osa_hwtimer_mapsk64</project><configuration>Int Flash Release</configuration></member><member><project>osa_msgq_mapsk64</project><configuration>Int Flash Release</configuration></member><member><project>osa_mutex_mapsk64</project><configuration>Int Flash Release</configuration></member><member><project>osa_semaphore_mapsk64</project><configuration>Int Flash Release</configuration></member></batchDefinition></batchBuild>
<project><path>$WS_DIR$\..\..\..\mqx\examples\demo\build\iar\demo_mapsk64\demo_mapsk64.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\event\build\iar\event_mapsk64\event_mapsk64.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\hello\build\iar\hello_mapsk64\hello_mapsk64.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\isr\build\iar\isr_mapsk64\isr_mapsk64.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\klog\build\iar\klog_mapsk64\klog_mapsk64.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\log\build\iar\log_mapsk64\log_mapsk64.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwdemo\build\iar\lwdemo_mapsk64\lwdemo_mapsk64.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwevent\build\iar\lwevent_mapsk64\lwevent_mapsk64.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwlog\build\iar\lwlog_mapsk64\lwlog_mapsk64.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwmsgq\build\iar\lwmsgq_mapsk64\lwmsgq_mapsk64.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\lwsem\build\iar\lwsem_mapsk64\lwsem_mapsk64.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\msg\build\iar\msg_mapsk64\msg_mapsk64.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\mutex\build\iar\mutex_mapsk64\mutex_mapsk64.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\nill\build\iar\nill_mapsk64\nill_mapsk64.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\sem\build\iar\sem_mapsk64\sem_mapsk64.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\taskat\build\iar\taskat_mapsk64\taskat_mapsk64.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\taskq\build\iar\taskq_mapsk64\taskq_mapsk64.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\test\build\iar\test_mapsk64\test_mapsk64.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\timer\build\iar\timer_mapsk64\timer_mapsk64.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples\watchdog\build\iar\watchdog_mapsk64\watchdog_mapsk64.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples_osa\event\build\iar\event_mapsk64\osa_event_mapsk64.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples_osa\hello\build\iar\hello_mapsk64\osa_hello_mapsk64.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples_osa\hwtimer\build\iar\hwtimer_mapsk64\osa_hwtimer_mapsk64.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples_osa\msgq\build\iar\msgq_mapsk64\osa_msgq_mapsk64.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples_osa\mutex\build\iar\mutex_mapsk64\osa_mutex_mapsk64.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\examples_osa\semaphore\build\iar\semaphore_mapsk64\osa_semaphore_mapsk64.ewp</path></project></workspace>
