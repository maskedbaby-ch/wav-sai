<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>all</name><member><project>bsp</project><configuration>Debug</configuration></member><member><project>bsp</project><configuration>Release</configuration></member><member><project>psp</project><configuration>Debug</configuration></member><member><project>psp</project><configuration>Release</configuration></member><member><project>nshell</project><configuration>Debug</configuration></member><member><project>nshell</project><configuration>Release</configuration></member><member><project>mqx_stdlib</project><configuration>Debug</configuration></member><member><project>mqx_stdlib</project><configuration>Release</configuration></member></batchDefinition><batchDefinition><name>debug</name><member><project>bsp_mapsk64</project><configuration>Debug</configuration></member><member><project>psp_mapsk64</project><configuration>Debug</configuration></member><member><project>nshell_mapsk64</project><configuration>Debug</configuration></member><member><project>mqx_stdlib_mapsk64</project><configuration>Debug</configuration></member></batchDefinition><batchDefinition><name>release</name><member><project>bsp_mapsk64</project><configuration>Release</configuration></member><member><project>psp_mapsk64</project><configuration>Release</configuration></member><member><project>nshell_mapsk64</project><configuration>Release</configuration></member><member><project>mqx_stdlib_mapsk64</project><configuration>Release</configuration></member></batchDefinition></batchBuild>
<project><path>$WS_DIR$\..\..\..\mqx\build\iar\bsp_mapsk64\bsp_mapsk64.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx\build\iar\psp_mapsk64\psp_mapsk64.ewp</path></project><project><path>$WS_DIR$\..\..\..\nshell\build\iar\nshell_mapsk64\nshell_mapsk64.ewp</path></project><project><path>$WS_DIR$\..\..\..\mqx_stdlib\build\iar\mqx_stdlib_mapsk64\mqx_stdlib_mapsk64.ewp</path></project></workspace>
