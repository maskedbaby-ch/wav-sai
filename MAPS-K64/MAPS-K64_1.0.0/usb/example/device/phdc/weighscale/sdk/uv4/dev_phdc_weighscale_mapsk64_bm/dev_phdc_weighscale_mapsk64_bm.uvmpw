<?xml version="1.0" encoding="UTF-8" standalone="no"?>
<ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd">
  <SchemaVersion>1.0</SchemaVersion>
  <Header>### uVision Project, (C) Keil Software</Header>
  <WorkspaceName>WorkSpace</WorkspaceName>
<project><PathAndName>../../../../../../../../lib/ksdk_platform_lib/uv4/K64F12/ksdk_platform_lib.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>../../../../../../../usb_core/device/build/uv4/usbd_sdk_mapsk64_bm/usbd_sdk_mapsk64_bm.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>dev_phdc_weighscale_mapsk64_bm.uvproj</PathAndName><NodeIsActive>1</NodeIsActive></project></ProjectWorkspace>
