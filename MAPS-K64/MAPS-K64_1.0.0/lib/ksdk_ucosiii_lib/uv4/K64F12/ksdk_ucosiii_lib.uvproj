# Keil uVision project ksdk_ucosiii_lib.uvproj, settings and files
target ksdk_ucosiii_lib Debug (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  output: ksdk_ucosiii_lib.lib (library)
  c flags: Optim=1 wLevel=2
  c define: DEBUG, CPU_MK64FN1M0VMD12, KEIL, FSL_RTOS_UCOSIII
  c misc: --library_interface=armcc  --library_type=standardlib --c99 --diag_suppress=1296,186
  c include: ../../../../rtos/uCOSIII/src/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView;../../../../rtos/uCOSIII/src/uC-CPU/ARM-Cortex-M4/RealView;../../../../rtos;../../../../rtos/uCOSIII/src/config;../../../../rtos/uCOSIII/src/uCOS-III/Source;../../../../rtos/uCOSIII/src/uC-LIB;../../../../rtos/uCOSIII/src/uC-CPU;../../../../platform/osa;../../../../platform/CMSIS/Include;../../../../platform/CMSIS/Include/device;../../../../platform/startup/MK64F12;../../../../platform/utilities;../../../../platform/hal/adc;../../../../platform/hal/can;../../../../platform/hal/dac;../../../../platform/hal/dma;../../../../platform/hal/dmamux;../../../../platform/hal/dspi;../../../../platform/hal/edma;../../../../platform/hal/enet;../../../../platform/hal/flextimer;../../../../platform/hal/flexbus;../../../../platform/hal/gpio;../../../../platform/hal/i2c;../../../../platform/hal/llwu;../../../../platform/hal/lptmr;../../../../platform/hal/mpu;../../../../platform/hal/mcg;../../../../platform/hal/osc;../../../../platform/hal/pdb;../../../../platform/hal/pit;../../../../platform/hal/pmc;../../../../platform/hal/port;../../../../platform/hal/rtc;../../../../platform/hal/sai;../../../../platform/hal/sdhc;../../../../platform/hal/sim;../../../../platform/hal/rcm;../../../../platform/hal/smc;../../../../platform/hal/spi;../../../../platform/hal/uart;../../../../platform/hal/wdog;../../../../platform/drivers;../../../../platform/drivers/adc;../../../../platform/drivers/adc/common;../../../../platform/drivers/can;../../../../platform/drivers/can/common;../../../../platform/drivers/dac;../../../../platform/drivers/dac/common;../../../../platform/drivers/dma;../../../../platform/drivers/dma/common;../../../../platform/drivers/edma;../../../../platform/drivers/edma/common;../../../../platform/drivers/dspi/dspi_master;../../../../platform/drivers/dspi/dspi_slave;../../../../platform/drivers/dspi/common;../../../../platform/drivers/enet;../../../../platform/drivers/enet/common;../../../../platform/drivers/enet/src;../../../../platform/drivers/flextimer;../../../../platform/drivers/flextimer/common;../../../../platform/drivers/gpio;../../../../platform/drivers/gpio/common;../../../../platform/drivers/i2c/i2c_master;../../../../platform/drivers/i2c/i2c_slave;../../../../platform/drivers/i2c/common;../../../../platform/drivers/lptmr;../../../../platform/drivers/lptmr/common;../../../../platform/drivers/mpu;../../../../platform/drivers/mpu/common;../../../../platform/drivers/lpuart;../../../../platform/drivers/lpuart/common;../../../../platform/drivers/pdb;../../../../platform/drivers/pdb/common;../../../../platform/drivers/pit;../../../../platform/drivers/pit/common;../../../../platform/drivers/rtc;../../../../platform/drivers/rtc/common;../../../../platform/drivers/sai;../../../../platform/drivers/sai/common;../../../../platform/drivers/sdhc;../../../../platform/drivers/sdhc/common;../../../../platform/drivers/sdcard;../../../../platform/drivers/spi/spi_master;../../../../platform/drivers/spi/spi_slave;../../../../platform/drivers/spi/common;../../../../platform/drivers/uart;../../../../platform/drivers/uart/common;../../../../platform/drivers/wdog;../../../../platform/drivers/wdog/common;../../../../platform/system/clock;../../../../platform/system/hwtimer;../../../../platform/system/interrupt;../../../../platform/system/power
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  group osa
    ../../../../platform/osa/: fsl_os_abstraction.h fsl_os_abstraction_ucosiii.h
    ../../../../platform/osa/src/: fsl_os_abstraction_ucosiii.c
  group platform-clock-system
    ../../../../platform/system/clock/: fsl_clock_manager.c fsl_clock_manager.h
    ../../../../platform/system/clock/MK64F12/: fsl_clock_K64F12.c fsl_clock_K64F12.h
  group platform-interrupt-system
    ../../../../platform/system/interrupt/src/: fsl_interrupt_manager.c
    ../../../../platform/system/interrupt/: fsl_interrupt_manager.h
  group platform-hwtimer-system
    ../../../../platform/system/hwtimer/src/: fsl_hwtimer.c fsl_hwtimer_pit.c fsl_hwtimer_systick.c
    ../../../../platform/system/hwtimer/: fsl_hwtimer.h fsl_hwtimer_pit.h fsl_hwtimer_systick.h
  group platform-power-system
    ../../../../platform/system/power/src/: fsl_power_manager.c
    ../../../../platform/system/power/: fsl_power_manager.h
  group platform-adc-hal
    ../../../../platform/hal/adc/: fsl_adc_features.h fsl_adc_hal.c fsl_adc_hal.h
  group platform-adc-drivers
    ../../../../platform/drivers/adc/: fsl_adc_driver.h
    ../../../../platform/drivers/adc/src/: fsl_adc_driver.c
  group platform-adc-common
    ../../../../platform/drivers/adc/common/: fsl_adc_common.h fsl_adc_common.c
  group platform-can-hal
    ../../../../platform/hal/can/: fsl_flexcan_features.h fsl_flexcan_hal.c fsl_flexcan_hal.h
  group platform-can-drivers
    ../../../../platform/drivers/can/src/: fsl_flexcan_driver.c
    ../../../../platform/drivers/can/: fsl_flexcan_driver.h
    ../../../../platform/drivers/can/common/: fsl_flexcan_common.c fsl_flexcan_common.h
  group platform-dac-hal
    ../../../../platform/hal/dac/: fsl_dac_features.h fsl_dac_hal.c fsl_dac_hal.h
  group platform-dac-drivers
    ../../../../platform/drivers/dac/src/: fsl_dac_driver.c
    ../../../../platform/drivers/dac/: fsl_dac_driver.h
  group platform-dac-common
    ../../../../platform/drivers/dac/common/: fsl_dac_common.c fsl_dac_common.h
  group platform-dmamux-hal
    ../../../../platform/hal/dmamux/: fsl_dmamux_hal.c fsl_dmamux_hal.h fsl_dmamux_features.h
  group platform-edma-hal
    ../../../../platform/hal/edma/: fsl_edma_features.h fsl_edma_hal.h fsl_edma_hal.c
  group platform-edma-drivers
    ../../../../platform/drivers/edma/: fsl_edma_driver.h fsl_edma_request.h
    ../../../../platform/drivers/edma/src/: fsl_edma_driver.c
  group platform-edma-common
    ../../../../platform/drivers/edma/common/: fsl_edma_common.c fsl_edma_common.h
  group platform-enet-hal
    ../../../../platform/hal/enet/: fsl_enet_features.h fsl_enet_hal.c fsl_enet_hal.h
  group platform-enet-drivers
    ../../../../platform/drivers/enet/src/: fsl_enet_driver.c
    ../../../../platform/drivers/enet/: fsl_enet_driver.h
  group platform-enet-common
    ../../../../platform/drivers/enet/common/: fsl_enet_common.c fsl_enet_common.h
  group platform-dspi-hal
    ../../../../platform/hal/dspi/: fsl_dspi_features.h fsl_dspi_hal.c fsl_dspi_hal.h
  group platform-dspi-drivers-common
    ../../../../platform/drivers/dspi/common/: fsl_dspi_shared_function.c fsl_dspi_shared_function.h fsl_dspi_common.c fsl_dspi_common.h
  group platform-dspi-drivers-master
    ../../../../platform/drivers/dspi/dspi_master/src/: fsl_dspi_master_driver.c fsl_dspi_master_driver_dma_support.c
  group platform-dspi-drivers-slave
    ../../../../platform/drivers/dspi/dspi_slave/src/: fsl_dspi_slave_driver.c fsl_dspi_slave_driver_dma_support.c
  group platform-flextimer-hal
    ../../../../platform/hal/flextimer/: fsl_ftm_features.h fsl_ftm_hal.c fsl_ftm_hal.h
  group platform-flextimer-drivers
    ../../../../platform/drivers/flextimer/src/: fsl_ftm_driver.c
    ../../../../platform/drivers/flextimer/: fsl_ftm_driver.h
    ../../../../platform/drivers/flextimer/common/: fsl_ftm_common.c fsl_ftm_common.h
  group platform-flexbus-hal
    ../../../../platform/hal/flexbus/: fsl_flexbus_hal.c fsl_flexbus_hal.h
  group platform-gpio-hal
    ../../../../platform/hal/gpio/: fsl_gpio_features.h fsl_gpio_hal.c fsl_gpio_hal.h
  group platform-gpio-common
    ../../../../platform/drivers/gpio/common/: fsl_gpio_common.c fsl_gpio_common.h
  group platform-gpio-drivers
    ../../../../platform/drivers/gpio/src/: fsl_gpio_driver.c
    ../../../../platform/drivers/gpio/: fsl_gpio_driver.h
  group platform-i2c-hal
    ../../../../platform/hal/i2c/: fsl_i2c_features.h fsl_i2c_hal.c fsl_i2c_hal.h
  group platform-i2c-drivers-common
    ../../../../platform/drivers/i2c/common/: fsl_i2c_shared_function.c fsl_i2c_shared_function.h fsl_i2c_common.c fsl_i2c_common.h
  group platform-i2c-drivers-master
    ../../../../platform/drivers/i2c/i2c_master/src/: fsl_i2c_master_driver.c
    ../../../../platform/drivers/i2c/i2c_master/: fsl_i2c_master_driver.h
  group platform-i2c-drivers-slave
    ../../../../platform/drivers/i2c/i2c_slave/src/: fsl_i2c_slave_driver.c
    ../../../../platform/drivers/i2c/i2c_slave/: fsl_i2c_slave_driver.h
  group platform-llwu-hal
    ../../../../platform/hal/llwu/: fsl_llwu_features.h fsl_llwu_hal.c fsl_llwu_hal.h
  group platform-lptmr-hal
    ../../../../platform/hal/lptmr/: fsl_lptmr_features.h fsl_lptmr_hal.c fsl_lptmr_hal.h
  group platform-lptmr-drivers
    ../../../../platform/drivers/lptmr/: fsl_lptmr_driver.h
    ../../../../platform/drivers/lptmr/src/: fsl_lptmr_driver.c
  group platform-lptmr-common
    ../../../../platform/drivers/lptmr/common/: fsl_lptmr_common.h fsl_lptmr_common.c
  group platform-mpu-hal
    ../../../../platform/hal/mpu/: fsl_mpu_features.h fsl_mpu_hal.c fsl_mpu_hal.h
  group platform-mpu-drivers
    ../../../../platform/drivers/mpu/: fsl_mpu_driver.h
    ../../../../platform/drivers/mpu/src/: fsl_mpu_driver.c
  group platform-mpu-common
    ../../../../platform/drivers/mpu/common/: fsl_mpu_common.h fsl_mpu_common.c
  group platform-mcg-hal
    ../../../../platform/hal/mcg/: fsl_mcg_hal.c fsl_mcg_hal.h fsl_mcg_hal_modes.c fsl_mcg_hal_modes.h
  group platform-osc-hal
    ../../../../platform/hal/osc/: fsl_osc_features.h fsl_osc_hal.c fsl_osc_hal.h
  group platform-pdb-hal
    ../../../../platform/hal/pdb/: fsl_pdb_features.h fsl_pdb_hal.c fsl_pdb_hal.h
  group platform-pdb-drivers
    ../../../../platform/drivers/pdb/src/: fsl_pdb_driver.c
    ../../../../platform/drivers/pdb/: fsl_pdb_driver.h
  group platform-pdb-common
    ../../../../platform/drivers/pdb/common/: fsl_pdb_common.c fsl_pdb_common.h
  group platform-pit-hal
    ../../../../platform/hal/pit/: fsl_pit_features.h fsl_pit_hal.c fsl_pit_hal.h
  group platform-pit-drivers
    ../../../../platform/drivers/pit/src/: fsl_pit_driver.c fsl_pit_irq.c
    ../../../../platform/drivers/pit/: fsl_pit_driver.h
  group platform-pit-common
    ../../../../platform/drivers/pit/common/: fsl_pit_common.c fsl_pit_common.h
  group platform-port-hal
    ../../../../platform/hal/port/: fsl_port_features.h fsl_port_hal.c fsl_port_hal.h
  group platform-rtc-hal
    ../../../../platform/hal/rtc/: fsl_rtc_features.h fsl_rtc_hal.c fsl_rtc_hal.h
  group platform-rtc-drivers
    ../../../../platform/drivers/rtc/src/: fsl_rtc_driver.c
    ../../../../platform/drivers/rtc/: fsl_rtc_driver.h
    ../../../../platform/drivers/rtc/common/: fsl_rtc_common.c fsl_rtc_common.h
  group platform-sai-hal
    ../../../../platform/hal/sai/: fsl_sai_features.h fsl_sai_hal.c fsl_sai_hal.h
  group platform-sai-drivers
    ../../../../platform/drivers/sai/src/: fsl_sai_driver.c
    ../../../../platform/drivers/sai/: fsl_sai_driver.h
  group platform-sai-common
    ../../../../platform/drivers/sai/common/: fsl_sai_common.c fsl_sai_common.h
  group platform-sdcard-drivers
    ../../../../platform/drivers/sdcard/src/: fsl_sdhc_card.c
  group platform-sdcard
    ../../../../platform/drivers/sdcard/: fsl_sdhc_card.h
  group platform-sdhc-hal
    ../../../../platform/hal/sdhc/: fsl_sdhc_features.h fsl_sdhc_hal.h fsl_sdhc_hal.c
  group platform-sdhc-drivers
    ../../../../platform/drivers/sdhc/src/: fsl_sdhc_driver.c
    ../../../../platform/drivers/sdhc/: fsl_sdhc_driver.h sdhc.h sdmmc.h
  group platform-sdhc-common
    ../../../../platform/drivers/sdhc/common/: fsl_sdhc_common.h fsl_sdhc_common.c
  group platform-sim-hal
    ../../../../platform/hal/sim/: fsl_sim_hal.c fsl_sim_hal.h
    ../../../../platform/hal/sim/MK64F12/: fsl_sim_hal_K64F12.c fsl_sim_hal_K64F12.h
  group platform-smc-hal
    ../../../../platform/hal/smc/: fsl_smc_hal.c fsl_smc_features.h fsl_smc_hal.h
  group platform-pmc-hal
    ../../../../platform/hal/pmc/: fsl_pmc_features.h fsl_pmc_hal.c fsl_pmc_hal.h
  group platform-rcm-hal
    ../../../../platform/hal/rcm/: fsl_rcm_features.h fsl_rcm_hal.c fsl_rcm_hal.h
  group platform-uart-hal
    ../../../../platform/hal/uart/: fsl_uart_features.h fsl_uart_hal.h fsl_uart_hal.c
  group platform-uart-drivers-common
    ../../../../platform/drivers/uart/common/: fsl_uart_common.c fsl_uart_common.h
  group platform-uart-drivers
    ../../../../platform/drivers/uart/src/: fsl_uart_driver.c
    ../../../../platform/drivers/uart/: fsl_uart_driver.h
  group platform-wdog-hal
    ../../../../platform/hal/wdog/: fsl_wdog_hal.c fsl_wdog_features.h fsl_wdog_hal.h
  group platform-wdog-drivers
    ../../../../platform/drivers/wdog/src/: fsl_wdog_driver.c
    ../../../../platform/drivers/wdog/: fsl_wdog_driver.h
  group platform-wdog-common
    ../../../../platform/drivers/wdog/common/: fsl_wdog_common.c fsl_wdog_common.h
target ksdk_ucosiii_lib Release (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  output: ksdk_ucosiii_lib.lib (library)
  c flags: Optim=1
  c define: NDEBUG, CPU_MK64FN1M0VMD12, KEIL, FSL_RTOS_UCOSIII
  c misc: as above
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
